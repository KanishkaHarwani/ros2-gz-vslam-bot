Commit message: edited the materials file

File: description/materials.xacro (robot description, xacro)
@@ -22,3 +22,6 @@
         <color rgba="1 0.3 0.1 1"/>
     </material>
+    <material name="desert_tan">
+        <color rgba="0.820 0.710 0.550 1.000"/>
+    </material>
 </robot>
